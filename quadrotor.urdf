Commit message: quadrotor + prop system added

File: quadrotor.urdf (robot description, URDF)
Before this commit: robot quadrotor, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://drake/examples/quadrotor/skydio_2_1000_poly.obj scale=.00254
